# Autodesk Inventor assembly: 21.2030 LINK
## iProperties
Created: 2007-01
Part Number: 21.2030 LINK
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
